** SPICE netlist generated by bigspicy.py at Sun Dec 11 11:18:06 2022 UTC
.SUBCKT iiitb_3bit_rc
+ VGND VPWR clk ori count.0 count.1 count.2
** replacing FILLER_0_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_0_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_0_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_29/VPB =>[signal: VPWR w=1]]']]
FILLER_0_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_41/VPB =>[signal: VPWR w=1]]']]
FILLER_0_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_0_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_57/VPB =>[signal: VPWR w=1]]']]
FILLER_0_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_69/VPB =>[signal: VPWR w=1]]']]
FILLER_0_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_0_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_85/VPB =>[signal: VPWR w=1]]']]
FILLER_0_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_9/VPB =>[signal: VPWR w=1]]']]
FILLER_0_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_10_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_15/VPB =>[signal: VPWR w=1]]']]
FILLER_10_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_29/VPB =>[signal: VPWR w=1]]']]
FILLER_10_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_3/VPB =>[signal: VPWR w=1]]']]
FILLER_10_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_41 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_47 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_68 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_68/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_68/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_68/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_68/VPB =>[signal: VPWR w=1]]']]
FILLER_10_68 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_80 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_80_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_80_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_10_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_85/VPB =>[signal: VPWR w=1]]']]
FILLER_10_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_11_101 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_11_15 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_11_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_3/VPB =>[signal: VPWR w=1]]']]
FILLER_11_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_36 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_36/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_36/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_36/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_36/VPB =>[signal: VPWR w=1]]']]
FILLER_11_36 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_48 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_11_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_57/VPB =>[signal: VPWR w=1]]']]
FILLER_11_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_69/VPB =>[signal: VPWR w=1]]']]
FILLER_11_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_81/VPB =>[signal: VPWR w=1]]']]
FILLER_11_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_93 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_12_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_15/VPB =>[signal: VPWR w=1]]']]
FILLER_12_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_29/VPB =>[signal: VPWR w=1]]']]
FILLER_12_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_3/VPB =>[signal: VPWR w=1]]']]
FILLER_12_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_41/VPB =>[signal: VPWR w=1]]']]
FILLER_12_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_53/VPB =>[signal: VPWR w=1]]']]
FILLER_12_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_65/VPB =>[signal: VPWR w=1]]']]
FILLER_12_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_12_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_85/VPB =>[signal: VPWR w=1]]']]
FILLER_12_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_13_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_15/VPB =>[signal: VPWR w=1]]']]
FILLER_13_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_29/VPB =>[signal: VPWR w=1]]']]
FILLER_13_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_3/VPB =>[signal: VPWR w=1]]']]
FILLER_13_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_41/VPB =>[signal: VPWR w=1]]']]
FILLER_13_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_13_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_13_65 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_70 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_70/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_70/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_70/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_70/VPB =>[signal: VPWR w=1]]']]
FILLER_13_70 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_82 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_13_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_85/VPB =>[signal: VPWR w=1]]']]
FILLER_13_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_1_101 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_1_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_15/VPB =>[signal: VPWR w=1]]']]
FILLER_1_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_27/VPB =>[signal: VPWR w=1]]']]
FILLER_1_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_3/VPB =>[signal: VPWR w=1]]']]
FILLER_1_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_39/VPB =>[signal: VPWR w=1]]']]
FILLER_1_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_57/VPB =>[signal: VPWR w=1]]']]
FILLER_1_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_69/VPB =>[signal: VPWR w=1]]']]
FILLER_1_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_81/VPB =>[signal: VPWR w=1]]']]
FILLER_1_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_93 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_2_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_15/VPB =>[signal: VPWR w=1]]']]
FILLER_2_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_29/VPB =>[signal: VPWR w=1]]']]
FILLER_2_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_3/VPB =>[signal: VPWR w=1]]']]
FILLER_2_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_41/VPB =>[signal: VPWR w=1]]']]
FILLER_2_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_53/VPB =>[signal: VPWR w=1]]']]
FILLER_2_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_65/VPB =>[signal: VPWR w=1]]']]
FILLER_2_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_2_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_85/VPB =>[signal: VPWR w=1]]']]
FILLER_2_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_3_101 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_3_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_15/VPB =>[signal: VPWR w=1]]']]
FILLER_3_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_27/VPB =>[signal: VPWR w=1]]']]
FILLER_3_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_3/VPB =>[signal: VPWR w=1]]']]
FILLER_3_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_39/VPB =>[signal: VPWR w=1]]']]
FILLER_3_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_3_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_57/VPB =>[signal: VPWR w=1]]']]
FILLER_3_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_69/VPB =>[signal: VPWR w=1]]']]
FILLER_3_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_81/VPB =>[signal: VPWR w=1]]']]
FILLER_3_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_93 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_4_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_15/VPB =>[signal: VPWR w=1]]']]
FILLER_4_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_4_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_29/VPB =>[signal: VPWR w=1]]']]
FILLER_4_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_3/VPB =>[signal: VPWR w=1]]']]
FILLER_4_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_41 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_4_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_65/VPB =>[signal: VPWR w=1]]']]
FILLER_4_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_4_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_4_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_85/VPB =>[signal: VPWR w=1]]']]
FILLER_4_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_5_101 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_5_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_15/VPB =>[signal: VPWR w=1]]']]
FILLER_5_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_27/VPB =>[signal: VPWR w=1]]']]
FILLER_5_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_3/VPB =>[signal: VPWR w=1]]']]
FILLER_5_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_39/VPB =>[signal: VPWR w=1]]']]
FILLER_5_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_5_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_57/VPB =>[signal: VPWR w=1]]']]
FILLER_5_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_69/VPB =>[signal: VPWR w=1]]']]
FILLER_5_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_81/VPB =>[signal: VPWR w=1]]']]
FILLER_5_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_93 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_6_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_15/VPB =>[signal: VPWR w=1]]']]
FILLER_6_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_6_29 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_6_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_3/VPB =>[signal: VPWR w=1]]']]
FILLER_6_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_37 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_37_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_37_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_6_60 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_60/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_60/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_60/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_60/VPB =>[signal: VPWR w=1]]']]
FILLER_6_60 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_72 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_72/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_72/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_72/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_72/VPB =>[signal: VPWR w=1]]']]
FILLER_6_72 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_85/VPB =>[signal: VPWR w=1]]']]
FILLER_6_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_101 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_7_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_15/VPB =>[signal: VPWR w=1]]']]
FILLER_7_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_27/VPB =>[signal: VPWR w=1]]']]
FILLER_7_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_3/VPB =>[signal: VPWR w=1]]']]
FILLER_7_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_39/VPB =>[signal: VPWR w=1]]']]
FILLER_7_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_7_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_57/VPB =>[signal: VPWR w=1]]']]
FILLER_7_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_69/VPB =>[signal: VPWR w=1]]']]
FILLER_7_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_81/VPB =>[signal: VPWR w=1]]']]
FILLER_7_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_93 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_8_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_15/VPB =>[signal: VPWR w=1]]']]
FILLER_8_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_29/VPB =>[signal: VPWR w=1]]']]
FILLER_8_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_3/VPB =>[signal: VPWR w=1]]']]
FILLER_8_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_41 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_8_67 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_67/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_67/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_67/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_67/VPB =>[signal: VPWR w=1]]']]
FILLER_8_67 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_79 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_79_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_79_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_8_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_85/VPB =>[signal: VPWR w=1]]']]
FILLER_8_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_9_101 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_9_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_15/VPB =>[signal: VPWR w=1]]']]
FILLER_9_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_27 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_9_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_3/VPB =>[signal: VPWR w=1]]']]
FILLER_9_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_54 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_9_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_57/VPB =>[signal: VPWR w=1]]']]
FILLER_9_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_69/VPB =>[signal: VPWR w=1]]']]
FILLER_9_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_81/VPB =>[signal: VPWR w=1]]']]
FILLER_9_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_93 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_24 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_26 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_28 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_29 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_30 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_31 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_32 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_33 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_34 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_35 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_36 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_37 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_38 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_39 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_40 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_41 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_42 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_43 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_44 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_45 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_46 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_47 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_48 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_49 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_50 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_51 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _6_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__6__0 _6__a_1270_413# _6__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__6__1 VPWR _6__a_543_47# _6__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__6__2 VGND _6__a_543_47# _6__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__6__3 VGND net2 _6__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__6__4 _6__a_1108_47# _6__a_193_47# _6__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__6__5 VGND _6__a_1283_21# net1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__6__6 _6__a_1217_47# _6__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__6__7 _6__a_448_47# _6__a_27_47# _6__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__6__8 _6__a_448_47# _6__a_193_47# _6__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__6__9 _6__a_543_47# _6__a_193_47# _6__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__6__10 _6__a_1108_47# _6__a_27_47# _6__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__6__11 _6__a_1462_47# _6__a_1108_47# _6__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__6__12 _6__a_543_47# _6__a_27_47# _6__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__6__13 _6__a_805_47# _0_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__6__14 _6__a_761_289# _6__a_193_47# _6__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__6__15 VPWR _0_ _6__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__6__16 VGND _6__a_27_47# _6__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__6__17 _6__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__6__18 _6__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__6__19 VPWR _6__a_1283_21# net1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__6__20 VPWR _6__a_27_47# _6__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__6__21 _6__a_1283_21# _6__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__6__22 VGND _0_ _6__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__6__23 VPWR net2 _6__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__6__24 _6__a_651_413# _6__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__6__25 _6__a_761_289# _6__a_27_47# _6__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__6__26 VPWR _0_ _6__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__6__27 _6__a_639_47# _6__a_761_289# _6__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _7_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__7__0 _7__a_1270_413# _7__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__7__1 VPWR _7__a_543_47# _7__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__7__2 VGND _7__a_543_47# _7__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__7__3 VGND net3 _7__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__7__4 _7__a_1108_47# _7__a_193_47# _7__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__7__5 VGND _7__a_1283_21# net2 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__7__6 _7__a_1217_47# _7__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__7__7 _7__a_448_47# _7__a_27_47# _7__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__7__8 _7__a_448_47# _7__a_193_47# _7__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__7__9 _7__a_543_47# _7__a_193_47# _7__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__7__10 _7__a_1108_47# _7__a_27_47# _7__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__7__11 _7__a_1462_47# _7__a_1108_47# _7__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__7__12 _7__a_543_47# _7__a_27_47# _7__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__7__13 _7__a_805_47# _1_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__7__14 _7__a_761_289# _7__a_193_47# _7__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__7__15 VPWR _1_ _7__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__7__16 VGND _7__a_27_47# _7__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__7__17 _7__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__7__18 _7__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__7__19 VPWR _7__a_1283_21# net2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__7__20 VPWR _7__a_27_47# _7__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__7__21 _7__a_1283_21# _7__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__7__22 VGND _1_ _7__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__7__23 VPWR net3 _7__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__7__24 _7__a_651_413# _7__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__7__25 _7__a_761_289# _7__a_27_47# _7__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__7__26 VPWR _1_ _7__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__7__27 _7__a_639_47# _7__a_761_289# _7__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _8_ with the contents of sky130_fd_sc_hd__dfstp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_562_413# w=1]]', 'g: [connection X0/g =>[signal: a_652_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__8__0 _8__a_562_413# _8__a_652_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1296_47# w=1]]', 'g: [connection X1/g =>[signal: SET_B w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__8__1 _8__a_1296_47# _2_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_381_47# w=1]]', 'g: [connection X2/g =>[signal: a_193_47# w=1]]', 's: [connection X2/s =>[signal: a_476_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__8__2 _8__a_381_47# _8__a_193_47# _8__a_476_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_1602_47# w=1]]', 'g: [connection X3/g =>[signal: a_1032_413# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__8__3 _8__a_1602_47# _8__a_1032_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1140_413# w=1]]', 'g: [connection X4/g =>[signal: a_1182_261# w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__8__4 _8__a_1140_413# _8__a_1182_261# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_1032_413# w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: a_1224_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__8__5 _8__a_1032_413# _8__a_27_47# _8__a_1224_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '540000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_1032_413# w=1]]', 's: [connection X6/s =>[signal: a_1182_261# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__8__6 VGND _8__a_1032_413# _8__a_1182_261# VGND sky130_fd_pr__nfet_01v8 W=540000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_476_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_562_413# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__8__7 _8__a_476_47# _8__a_27_47# _8__a_562_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_476_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__8__8 _8__a_381_47# _8__a_27_47# _8__a_476_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: a_476_47# w=1]]', 's: [connection X9/s =>[signal: a_1056_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__8__9 VGND _8__a_476_47# _8__a_1056_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1602_47# w=1]]', 'g: [connection X10/g =>[signal: a_1032_413# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__8__10 _8__a_1602_47# _8__a_1032_413# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1056_47# w=1]]', 'g: [connection X11/g =>[signal: a_193_47# w=1]]', 's: [connection X11/s =>[signal: a_1032_413# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__8__11 _8__a_1056_47# _8__a_193_47# _8__a_1032_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: SET_B w=1]]', 's: [connection X12/s =>[signal: a_652_21# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__8__12 VPWR _2_ _8__a_652_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_796_47# w=1]]', 'g: [connection X13/g =>[signal: a_476_47# w=1]]', 's: [connection X13/s =>[signal: a_652_21# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__8__13 _8__a_796_47# _8__a_476_47# _8__a_652_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: VPWR w=1]]', 'g: [connection X14/g =>[signal: a_476_47# w=1]]', 's: [connection X14/s =>[signal: a_956_413# w=1]]', 'b: [connection X14/b =>[signal: VPB w=1]]']]
X__8__14 VPWR _8__a_476_47# _8__a_956_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_586_47# w=1]]', 'g: [connection X15/g =>[signal: a_652_21# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__8__15 _8__a_586_47# _8__a_652_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VPWR w=1]]', 'g: [connection X16/g =>[signal: D w=1]]', 's: [connection X16/s =>[signal: a_381_47# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__8__16 VPWR net1 _8__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_652_21# w=1]]', 'g: [connection X17/g =>[signal: a_476_47# w=1]]', 's: [connection X17/s =>[signal: VPWR w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__8__17 _8__a_652_21# _8__a_476_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_1032_413# w=1]]', 'g: [connection X18/g =>[signal: a_193_47# w=1]]', 's: [connection X18/s =>[signal: a_1140_413# w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__8__18 _8__a_1032_413# _8__a_193_47# _8__a_1140_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_1602_47# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__8__19 VGND _8__a_1602_47# net3 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X20 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_476_47# w=1]]', 'g: [connection X20/g =>[signal: a_193_47# w=1]]', 's: [connection X20/s =>[signal: a_586_47# w=1]]', 'b: [connection X20/b =>[signal: VNB w=1]]']]
X__8__20 _8__a_476_47# _8__a_193_47# _8__a_586_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1032_413# w=1]]', 'g: [connection X21/g =>[signal: SET_B w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__8__21 _8__a_1032_413# _2_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__8__22 VGND _8__a_27_47# _8__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_956_413# w=1]]', 'g: [connection X23/g =>[signal: a_27_47# w=1]]', 's: [connection X23/s =>[signal: a_1032_413# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__8__23 _8__a_956_413# _8__a_27_47# _8__a_1032_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_27_47# w=1]]', 'g: [connection X24/g =>[signal: CLK w=1]]', 's: [connection X24/s =>[signal: VGND w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__8__24 _8__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_27_47# w=1]]', 'g: [connection X25/g =>[signal: CLK w=1]]', 's: [connection X25/s =>[signal: VPWR w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__8__25 _8__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: a_1032_413# w=1]]', 's: [connection X26/s =>[signal: a_1182_261# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__8__26 VPWR _8__a_1032_413# _8__a_1182_261# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_1224_47# w=1]]', 'g: [connection X27/g =>[signal: a_1182_261# w=1]]', 's: [connection X27/s =>[signal: a_1296_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__8__27 _8__a_1224_47# _8__a_1182_261# _8__a_1296_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_27_47# w=1]]', 's: [connection X28/s =>[signal: a_193_47# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__8__28 VPWR _8__a_27_47# _8__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: D w=1]]', 's: [connection X29/s =>[signal: a_381_47# w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X__8__29 VGND net1 _8__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: VGND w=1]]', 'g: [connection X30/g =>[signal: SET_B w=1]]', 's: [connection X30/s =>[signal: a_796_47# w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X__8__30 VGND _2_ _8__a_796_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: VPWR w=1]]', 'g: [connection X31/g =>[signal: a_1602_47# w=1]]', 's: [connection X31/s =>[signal: Q w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X__8__31 VPWR _8__a_1602_47# net3 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing clkbuf_0_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_0 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_1 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_2 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_3 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_4 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_5 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_6 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_7 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_8 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_9 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_10 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_11 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_12 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_13 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_14 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_15 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_16 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_17 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_18 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_19 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_20 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_21 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_22 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_23 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_24 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_25 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_26 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_27 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_28 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_29 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_30 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_31 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_32 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_33 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_34 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_35 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_36 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_37 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_38 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_39 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_0__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_0 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_1 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_2 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_3 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_4 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_5 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_6 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_7 VPWR clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_8 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_9 VGND clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_10 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_11 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_12 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_13 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_14 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_15 VPWR clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_16 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_17 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_18 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_19 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_20 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_21 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_22 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_23 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_24 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_25 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_26 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_27 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_28 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_29 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_30 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_31 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_32 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_33 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_34 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_35 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_36 VGND clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_37 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_38 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_39 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_1__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_0 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_1 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_2 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_3 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_4 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_5 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_6 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_7 VPWR clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_8 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_9 VGND clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_10 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_11 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_12 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_13 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_14 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_15 VPWR clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_16 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_17 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_18 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_19 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_20 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_21 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_22 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_23 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_24 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_25 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_26 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_27 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_28 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_29 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_30 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_31 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_32 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_33 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_34 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_35 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_36 VGND clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_37 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_38 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_39 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output1 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output1_0 count.0 output1_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output1_1 output1_a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output1_2 VGND output1_a_27_47# count.0 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output1_3 count.0 output1_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output1_4 VPWR output1_a_27_47# count.0 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output1_5 output1_a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output2 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output2_0 count.1 output2_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output2_1 output2_a_27_47# net2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output2_2 VGND output2_a_27_47# count.1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output2_3 count.1 output2_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output2_4 VPWR output2_a_27_47# count.1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output2_5 output2_a_27_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output3 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output3_0 count.2 output3_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output3_1 output3_a_27_47# net3 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output3_2 VGND output3_a_27_47# count.2 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output3_3 count.2 output3_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output3_4 VPWR output3_a_27_47# count.2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output3_5 output3_a_27_47# net3 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
